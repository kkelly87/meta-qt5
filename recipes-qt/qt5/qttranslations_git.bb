require qt5-git.inc
require ${PN}.inc

SRCREV = "3aad4ab4718d4bf952275a07e406e93eb6a22eed"
